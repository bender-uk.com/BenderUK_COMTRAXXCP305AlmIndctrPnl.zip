Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-25T12:13:25
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcBuildingElementProxy: NBS_BenderUK_MdclIsolatedPwrSplyUnitsIPSRmtAlmPnls_COMTRAXXCP305AlarmIndicatorPanel:COMTRAXXCP305AlarmIndicatorPanel, NBS_BenderUK_MdclIsolatedPwrSplyUnitsIPSRmtAlmPnls_COMTRAXXCP305AlarmIndicatorPanel:COMTRAXXCP305AlarmIndicatorPanel:320800
In: Level 0
Type - Classification: Pr_60_70_64_52 (Uniclass2015); Material: <Unnamed>, NBS_BenderUK_Grey (2), NBS_BenderUK_DisplayScreen (2), NBS_BenderUK_White (2)
Type - IFC - IfcExportAs: IfcUnitaryControlElementType; IfcExportType: CONTROLPANEL
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_60_70_64_52:Medical isolated power supply units (IPS) remote alarm panels; Color: n/a; Finish: n/a; Material: Glass; Shape: Rectangle; Size: n/a; WarrantyDescription: Two year; CodePerformance: n/a; Constituents: n/a; Description: Remote alarm indicator, according to IEC 60364-7-710, for medical locations and other areas.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: marketing@bender-uk.com; ModelNumber: n/a; ModelReference: COMTRAXX® CP305 Alarm Indicator Panel; Name: MedicalIsolatedPowerSupplyUnitsIPSRemoteAlarmPanels_COMTRAXXCP305AlarmIndicatorPanel_BenderUK; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_BenderUK_MedicalIsolatedPowerSupplyUnitsIPSRemoteAlarmPanels_COMTRAXXCP305AlarmIndicatorPanel; ManufacturerName: Bender UK; ManufacturerURL: www.bender-uk.com; ProductInformation: https://source.thenbs.com/product/-/075f6009-cb7a-4d08-ae11-ee2c8edab379/35590045-c6d9-4be7-840f-e45db7123dfc; Uniclass2015Code: Pr_60_70_64_52; Uniclass2015Title: Medical isolated power supply units (IPS) remote alarm panels; Uniclass2015Version: Products v1.35; Version: 6
Type - NBS_Data - Standards: To IEC 60364-7-710; Certification: UL certified; Accessories: None,Flush-mounting enclosure (B923710),Cavity wall installation set for flush mounting enclosure (B923711),CP305 surface-mounting enclosure (B95100153),CP305-IO plug kit (B95100151),Ethernet adapter kit (RJ45 socket insert, Cat.6 SLIM patch cable) (B95100152); CountryOfProductManufacture: Germany; Material: Glass; ManufacturingPlantLocation: Londorfer Str. 65, 35305 Grünberg, Germany; Recyclability: Items at end of life can be returned to the manufacturer for recycling under WEEE regulations; Display: 5" TFT touch display (720 x 1280 px); Functions: Display functions: Normal operation indicator, Insulation fault, Overload, Overtemperature, Interruption of the system conductor or PE conductor connection of the ISOMETER®, Supply line failure, Power supply fault conditions and changeover device faults, Device failure, Test results, Measured values; IngressProtection: IP54 (entire device); IP66 (front glass pane); Input: 12 digital inputs; Interfaces: RJ45, Ethernet/Modbus TCP, RS485/BMS internal; Mounting: Flush-mounted,Surface-mounted,Cavity wall/ panel mounted,Retrofit replacement of MK2430; Output: 2 relay outputs
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcDistributionPort, Port_320800
Description: Flow; FlowDirection: SOURCEANDSINK
